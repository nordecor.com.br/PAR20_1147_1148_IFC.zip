Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-03-12T12:18:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 12 12:18:23 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\eff958be-4609-4445-b59b-83dc72d2a843\a392348f-8f15-4887-9840-7b4061cbc518\ifc * Database version: 5507 * Database creation date: Wed Mar 12 12:18:21 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 12 12:18:22 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 12 12:18:22 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328313
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 1147, Lâmpada_PAR20_1147_1148_Nordecor_IFC:1147:328313
In: Nível 1
Type - Material: Plástico - Branco - Fosco, Metal - Ferro, Plástico - Acrilico - Translucido, LED
Type - Cotas - Altura: 81 mm; Diâmetro: 63 mm
Type - Dados - Data de atualização: 18/06/2024; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Lâmpada de LED PAR20 7W 2700K 38º Dimerizáel 127V; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú-SC / Brasil; Modelo: 1147; Nome do tipo: 1147; Número OmniClass: 23.80.70.00; Observação: Não dimerizável; Tipo de imagem: Imagem raster: PAR20.png; Título OmniClass: Lighting; URL: https://www.brilia.com; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/lampada-led-par20-dimerizavel-7w-2-700k-irc95/; Vida útil: 25.000h
Type - Elétrico - Comentários de voltagem: 100-240VAC; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Lâmpada: 0 W
Type - Engenharia elétrica - Corrente elétrica: 0 A; Fator de potência - Lâmpada: 0.7; Voltagem - Lâmpada: 127 V
Type - Estrutural - Peso: 0.04kg
Type - Fotométricos - Ângulo de abertura: 38 deg; Fluxo luminoso: 525 lm; IRC: 95; Potência: 7 W; Temperatura de cor: 2700 K
Type - Materiais e acabamentos - PAR20: Alumínio e polímero sintético
Type - Outros - Categoria: Luminárias; 2700K - 38º: yes; Branco: yes; Nome da família: Lâmpada_PAR20_1147_1148_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Cotas - Área: 0.0106243 m2; Volume: 0.0000885303 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 127 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Lâmpada_PAR20_1147_1148_Nordecor_IFC: 1147; Família e tipo: Lâmpada_PAR20_1147_1148_Nordecor_IFC: 1147; ID de tipo: Lâmpada_PAR20_1147_1148_Nordecor_IFC: 1147; Tipo: Lâmpada_PAR20_1147_1148_Nordecor_IFC: 1147
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
